<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dab_mer</value></param>
<param><key>author</key><value>Serge G</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>DAB Mode I Mer Calc</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_gap__</value></param>
<param><key>value</key><value>[30, 10, 5, 20]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_length__</value></param>
<param><key>value</key><value>[504, 126, 63, 252]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dab_mode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length__</value></param>
<param><key>value</key><value>[2048, 512, 256, 1024]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_length__</value></param>
<param><key>value</key><value>[196608, 49152, 49152, 98304]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ns_length__</value></param>
<param><key>value</key><value>[2656, 664, 345, 1328]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_carriers__</value></param>
<param><key>value</key><value>[1536, 384, 192, 768]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phase_var_estimate_alpha</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phase_var_estimate_downsample</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_length__</value></param>
<param><key>value</key><value>[2552, 638, 319, 1276]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_for_ffs_estimation__</value></param>
<param><key>value</key><value>[8,8,16,8]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_for_magnitude_equalization__</value></param>
<param><key>value</key><value>[6,6,12,6]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_per_frame__</value></param>
<param><key>value</key><value>[76, 76, 153, 76]</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
<param><key>vlen</key><value>num_carriers__[dab_mode-1]</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>phase_var_estimate_downsample</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>num_carriers__[dab_mode-1]</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>num_carriers__[dab_mode-1]</value></param>
</block>
<block>
<key>dab_modulo_ff</key>
<param><key>id</key><value>dab_modulo_ff_0</value></param>
<param><key>div_f</key><value>1.5707963</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>iir_filter_xxx_0</value></param>
<param><key>fftaps</key><value>[phase_var_estimate_alpha]</value></param>
<param><key>fbtaps</key><value>[0,1-phase_var_estimate_alpha]</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>iir_filter_xxx_0_0</value></param>
<param><key>fftaps</key><value>[phase_var_estimate_alpha]</value></param>
<param><key>fbtaps</key><value>[0,1-phase_var_estimate_alpha]</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1536</value></param>
</block>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>iir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>dab_modulo_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_modulo_ff_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_modulo_ff_0</source_block_id><sink_block_id>iir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
