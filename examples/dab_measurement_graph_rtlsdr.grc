<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dab_whole_graph</value></param>
<param><key>author</key><value>Serge G</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Constellation+MER+Spectrum (all blocks are extracted)</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>DAB Measurement tool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_gap__</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[30, 10, 5, 20]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_gap__</value></param>
<param><key>value</key><value>[252, 63, 31, 124]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_length__</value></param>
<param><key>value</key><value>[504, 126, 63, 252]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dab_mode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length__</value></param>
<param><key>value</key><value>[2048, 512, 256, 1024]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_length__</value></param>
<param><key>value</key><value>[196608, 49152, 49152, 98304]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ns_length__</value></param>
<param><key>value</key><value>[2656, 664, 345, 1328]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_carriers__</value></param>
<param><key>value</key><value>[1536, 384, 192, 768]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2048000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_length__</value></param>
<param><key>value</key><value>[2552, 638, 319, 1276]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_for_ffs_estimation__</value></param>
<param><key>value</key><value>[8,8,16,8]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_for_magnitude_equalization__</value></param>
<param><key>value</key><value>[6,6,12,6]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_per_frame__</value></param>
<param><key>value</key><value>[76, 76, 153, 76]</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>analog_frequency_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>(fft_length__[dab_mode-1]+cp_length__[dab_mode-1])*symbols_for_ffs_estimation__[dab_mode-1]</value></param>
<param><key>minoutbuf</key><value>4096</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>(fft_length__[dab_mode-1]+cp_length__[dab_mode-1])*symbols_for_ffs_estimation__[dab_mode-1]</value></param>
<param><key>minoutbuf</key><value>4096</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_peak_detector_xb</key>
<param><key>id</key><value>blocks_peak_detector_xb_0_0</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>type</key><value>float</value></param>
<param><key>look_ahead</key><value>10</value></param>
<param><key>threshold_factor_fall</key><value>0.7</value></param>
<param><key>threshold_factor_rise</key><value>0.6</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1536</value></param>
</block>
<block>
<key>dab_diff_phasor_vcc</key>
<param><key>id</key><value>dab_diff_phasor_vcc_0</value></param>
<param><key>num_carriers</key><value>num_carriers__[dab_mode-1]</value></param>
</block>
<block>
<key>dab_mer</key>
<param><key>id</key><value>dab_mer_0</value></param>
</block>
<block>
<key>dab_moving_sum_ff</key>
<param><key>id</key><value>dab_moving_sum_ff_0</value></param>
<param><key>length</key><value>ns_length__[dab_mode-1]</value></param>
</block>
<block>
<key>dab_ofdm_coarse_frequency_correct</key>
<param><key>id</key><value>dab_ofdm_coarse_frequency_correct_0</value></param>
<param><key>cp_length</key><value>cp_length__[dab_mode-1]</value></param>
<param><key>num_carriers</key><value>num_carriers__[dab_mode-1]</value></param>
<param><key>fft_length</key><value>fft_length__[dab_mode-1]</value></param>
</block>
<block>
<key>dab_ofdm_ffe_all_in_one</key>
<param><key>id</key><value>dab_ofdm_ffe_all_in_one_0</value></param>
<param><key>fft_length</key><value>fft_length__[dab_mode-1]</value></param>
<param><key>num_symbols</key><value>symbols_for_ffs_estimation__[dab_mode-1]</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>symbol_length</key><value>fft_length__[dab_mode-1]+cp_length__[dab_mode-1]</value></param>
<param><key>alpha</key><value>0.5</value></param>
</block>
<block>
<key>dab_ofdm_remove_first_symbol_vcc</key>
<param><key>id</key><value>dab_ofdm_remove_first_symbol_vcc_0</value></param>
<param><key>num_carriers</key><value>num_carriers__[dab_mode-1]</value></param>
</block>
<block>
<key>dab_ofdm_sampler</key>
<param><key>id</key><value>dab_ofdm_sampler_0</value></param>
<param><key>cp_length</key><value>cp_length__[dab_mode-1]</value></param>
<param><key>fft_length</key><value>fft_length__[dab_mode-1]</value></param>
<param><key>gap</key><value>cp_gap__[dab_mode-1]</value></param>
<param><key>symbols_per_frame</key><value>symbols_per_frame__[dab_mode-1]</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_length__[dab_mode-1]</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>[]</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>68</value></param>
<param><key>freq0</key><value>194064e3</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0.2</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>True</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>10</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Input Spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win_size</key><value>450,400</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0</value></param>
<param><key>avg_alpha</key><value>0.2</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>factor</key><value>100.0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>number_rate</key><value>25</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0.01</value></param>
<param><key>samp_rate</key><value>100</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Modulation Error</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>% MER</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>1200000</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>I/Q Display</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>win_size</key><value>450,400</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>y_axis_label</key><value>I/Q</value></param>
</block>
<connection><source_block_id>analog_frequency_modulator_fc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>dab_moving_sum_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>dab_ofdm_sampler_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_peak_detector_xb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>dab_ofdm_sampler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector_xb_0_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector_xb_0_0</source_block_id><sink_block_id>dab_ofdm_ffe_all_in_one_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_diff_phasor_vcc_0</source_block_id><sink_block_id>dab_ofdm_remove_first_symbol_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_mer_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_moving_sum_ff_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_coarse_frequency_correct_0</source_block_id><sink_block_id>dab_diff_phasor_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_coarse_frequency_correct_0</source_block_id><sink_block_id>dab_ofdm_remove_first_symbol_vcc_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dab_ofdm_ffe_all_in_one_0</source_block_id><sink_block_id>analog_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_remove_first_symbol_vcc_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_remove_first_symbol_vcc_0</source_block_id><sink_block_id>dab_mer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_remove_first_symbol_vcc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_sampler_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_sampler_0</source_block_id><sink_block_id>dab_ofdm_coarse_frequency_correct_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>dab_ofdm_coarse_frequency_correct_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>dab_ofdm_ffe_all_in_one_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
