<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>adjust_gui_helpers.id_to_frequency(frequency_id)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frequency_id</value></param>
<param><key>value</key><value>frequency_id_default</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>adjust_gui_helpers.get_number_of_channels()-1</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_bb</value></param>
<param><key>value</key><value>gain_bb_default</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Gain BB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_if</value></param>
<param><key>value</key><value>gain_if_default</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Gain IF</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_slider</value></param>
<param><key>value</key><value>gain_rf_default</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Gain RF</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ppm</value></param>
<param><key>value</key><value>ppm_default</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>variable_qtgui_push_button_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>6,0,1,1</value></param>
<param><key>label</key><value>Save adjustments to configuration file</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1536</value></param>
</block>
<block>
<key>dab_ofdm_demod</key>
<param><key>id</key><value>dab_ofdm_demod_0</value></param>
<param><key>autocorr_sr</key><value>False</value></param>
<param><key>dab_mode</key><value>1</value></param>
<param><key>eq_mag</key><value>True</value></param>
<param><key>correct_ffe</key><value>True</value></param>
<param><key>input_fft</key><value>True</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>soft_bits</key><value>soft</value></param>
<param><key>ppm_error</key><value>ppm</value></param>
</block>
<block>
<key>dab_osmo_or_zmq_source</key>
<param><key>id</key><value>dab_osmo_or_zmq_source_0</value></param>
<param><key>bb_gain</key><value>gain_bb</value></param>
<param><key>frequency</key><value>frequency</value></param>
<param><key>if_gain</key><value>gain_if</value></param>
<param><key>rf_gain</key><value>gain_slider</value></param>
<param><key>server_control</key><value>server_control</value></param>
<param><key>server</key><value>server</value></param>
<param><key>zeromq</key><value>zeromq</value></param>
</block>
<block>
<key>digital_mpsk_snr_est_cc</key>
<param><key>id</key><value>digital_mpsk_snr_est_cc_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>tag_nsamples</key><value>10000</value></param>
<param><key>type</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency_id_default</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_bb_default</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_if_default</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_rf_default</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import adjust_gui_helpers</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm_default</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>gui_hint</key><value>5,1,5,1</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,1,5,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:10444"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_control</value></param>
<param><key>value</key><value>"tcp://127.0.0.1:10445"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>zeromq</value></param>
<param><key>value</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>digital_mpsk_snr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_ofdm_demod_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_osmo_or_zmq_source_0</source_block_id><sink_block_id>dab_ofdm_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dab_osmo_or_zmq_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_mpsk_snr_est_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
