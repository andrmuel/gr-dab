options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: adjust_gui_helpers.id_to_frequency(frequency_id)
  states: {}
- name: frequency_id
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: adjust_gui_helpers.get_number_of_channels()-1
    value: frequency_id_default
  states: {}
- name: gain_bb
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Gain BB
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: gain_bb_default
  states: {}
- name: gain_if
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Gain IF
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: gain_if_default
  states: {}
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Gain RF
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: gain_rf_default
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: '-1000'
    step: '1'
    stop: '1000'
    value: ppm_default
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: variable_qtgui_push_button_0
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 6,0,1,1
    label: Save adjustments to configuration file
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1536'
    type: complex
  states: {}
- name: dab_ofdm_demod_0
  id: dab_ofdm_demod
  parameters:
    autocorr_sr: 'False'
    correct_ffe: 'True'
    dab_mode: '1'
    eq_mag: 'True'
    input_fft: 'True'
    ppm_error: ppm
    samp_rate: samp_rate
    soft_bits: soft
  states: {}
- name: dab_osmo_or_zmq_source_0
  id: dab_osmo_or_zmq_source
  parameters:
    bb_gain: gain_bb
    frequency: frequency
    from_file: from_file
    from_file_repeat: from_file_repeat
    if_gain: gain_if
    rf_gain: gain_slider
    samp_rate: samp_rate
    server: server
    server_control: server_control
    zeromq: zeromq
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '0'
  states: {}
- name: frequency_id_default
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: from_file
  id: parameter
  parameters:
    value: None
  states: {}
- name: from_file_repeat
  id: parameter
  parameters:
    value: 'False'
  states: {}
- name: gain_bb_default
  id: parameter
  parameters:
    value: '10'
  states: {}
- name: gain_if_default
  id: parameter
  parameters:
    value: '10'
  states: {}
- name: gain_rf_default
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import adjust_gui_helpers
  states: {}
- name: ppm_default
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 5,1,5,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    gui_hint: 0,1,5,1
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: server
  id: parameter
  parameters:
    value: '"tcp://127.0.0.1:10444"'
  states: {}
- name: server_control
  id: parameter
  parameters:
    value: '"tcp://127.0.0.1:10445"'
  states: {}
- name: zeromq
  id: parameter
  parameters:
    value: 'False'
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [dab_ofdm_demod_0, '0', blocks_vector_to_stream_0, '0']
- [dab_osmo_or_zmq_source_0, '0', dab_ofdm_demod_0, '0']
- [dab_osmo_or_zmq_source_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', qtgui_const_sink_x_1, '0']

metadata:
  file_format: 1
